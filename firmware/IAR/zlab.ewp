# IAR project zlab.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..\stm32\CMSIS; ..\stm32\STM32F3xx; ..\stm32\USB\stm32f3xx_hal; ..\stm32\USB\system; ..\stm32\USB\user; ..\user; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: zlab.srec
  ILINK.IlinkOutputFile: zlab.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group comm
    ../comm/: comm.c comm.h sump.c sump.h
  group driver
    ../driver/: digit_in.c digit_in.h driver.c driver.h pwm_out.c pwm_out.h
  group hal
    ../hal/: bits.h dma.h gpio.h timer.h
  group STM32/CMSIS
    ../stm32/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group STM32/STM32F3xx
    ./: startup_stm32f303xc.s
    ../stm32/STM32F3xx/: stm32f303xc.h stm32f3xx.h stm32f3xx_it.c stm32f3xx_it.h system_stm32f3xx.c system_stm32f3xx.h
  group STM32/USB/STM32_HAL
    ../stm32/USB/stm32f3xx_hal/: stm32f3xx_hal.c stm32f3xx_hal.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.c stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.c stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_msp.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc_ex.h
  group STM32/USB/system
    ../stm32/USB/system/: usbd_cdc.c usbd_cdc.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_ioreq.c usbd_ioreq.h
  group STM32/USB/user
    ../stm32/USB/user/: usb_cdc_device.c usb_cdc_device.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group user
    ../user/: config.h heap.c heap.h main.c main.h
